# Keil uVision project PWM.uvprojx, settings and files
target Car (5060960::V5.06 update 7 (build 960)::.\ARM5)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\PWM;..\FWLIB\inc;..\HARDWARE\motor;..\HARDWARE\speed;..\HARDWARE\timer;..\HARDWARE\datascope;..\HARDWARE\show;..\HARDWARE\pid;..\HARDWARE\bluetooth;..\HARDWARE\iic;..\HARDWARE\oled;..\HARDWARE\csrc;..\HARDWARE\adc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/speed/: speed.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/datascope/: DataScope_DP.C
    ../HARDWARE/show/: show.c
    ../HARDWARE/pid/: pid.c
    ../HARDWARE/bluetooth/: bluetooth.c
    ../HARDWARE/oled/: oled.c
    ../HARDWARE/adc/: adc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_adc.c
  group README
    ../: readme.txt
